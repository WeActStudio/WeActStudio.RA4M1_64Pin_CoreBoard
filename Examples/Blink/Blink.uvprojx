# Keil uVision project Blink.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA4M1AB Renesas
  pack: Renesas.RA_DFP.4.5.0
  cpu: CPUTYPE("Cortex-M4")    FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: Blink +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
